FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-toradex-2016.11:"

SRC_URI += "file://0001-changing-dtb-and-vidargs.patch \
	 	    "